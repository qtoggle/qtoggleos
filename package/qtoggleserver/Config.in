## package/qtoggleserver/Config.in
```kconfig
config BR2_PACKAGE_QTOGGLESERVER
	bool "qtoggleserver"
	depends on BR2_PACKAGE_PYTHON3
```
